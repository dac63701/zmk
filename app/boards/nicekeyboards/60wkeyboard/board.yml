## app/boards/nicekeyboards/60wkeyboard/board.yml
```yaml
board:
  name: 60wkeyboard
  vendor: nicekeyboards
  socs:
    - name: nrf52840
      variants:
        - name: zmk
```
